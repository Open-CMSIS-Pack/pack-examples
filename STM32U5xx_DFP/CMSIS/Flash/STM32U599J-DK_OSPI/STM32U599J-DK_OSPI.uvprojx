# Keil uVision project STM32U599J-DK_OSPI.uvprojx, settings and files
target STM32U599J-DK (6190000::V6.19::ARMCLANG)
  device: STM32U599NJHxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.2.0-dev0
  cpu: IRAM(0x20000000,0x00270000) IRAM2(0x24000000,0x01000000) IROM(0x08000000,0x00400000) XRAM(0x28000000,0x00004000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MX25LM51245G_STM32U599J-DK
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM, USE_HAL_DRIVER, USE_IOEXPANDER
  c include: .\;.\OSPI
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT6: RAM 0x28000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x270000
  memory RVCT10: RAM 0x24000000 size 0x1000000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./OSPI/: STM32U5OSPI.c mx25lm51245g.c stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c system_stm32u5xx.c stm32u5xx_ll_dlyb.c stm32u599j_discovery_ospi.c
software components: CMSIS:CORE 5.6.0
