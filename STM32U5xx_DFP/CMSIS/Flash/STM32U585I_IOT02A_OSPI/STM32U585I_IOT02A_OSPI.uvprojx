# Keil uVision project STM32U585I_IOT02A_OSPI.uvprojx, settings and files
target STM32U585I_IOT02A_OSPI (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0-dev11
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MX25LM51245G_STM32U585I_IOT02A
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=3
  c define: FLASH_MEM,USE_HAL_DRIVER,USE_IOEXPANDER, CORE_CM33,STM32U575xx
  c include: .\OSPI
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./OSPI/: mx25lm51245g.c stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_flash.c stm32u5xx_hal_gpio.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c system_stm32u5xx.c STM32U5OSPI.c stm32u5xx_hal_flash_ex.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_ospi.c b_u585i_iot02a_ospi.c aps6408.c stm32u5xx_hal_dma_ex.c
software components: CMSIS:CORE 5.6.0
