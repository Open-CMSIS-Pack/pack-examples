# Keil uVision project STM32U5x9J-DK_OSPI.uvprojx, settings and files
target STM32U5x9J-DK (6180000::V6.18::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: MX25LM51245G_STM32U5x9J-DK
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=2
  c define: FLASH_MEM,USE_HAL_DRIVER,STM32U599xx,USE_IOEXPANDER ,CORE_CM33
  c include: ./;.\OSPI;.\OSPI\Core\Include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: .\loader.sct
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group OSPI
    ./OSPI/: Loader_Src.c mx25lm51245g.c stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_ospi.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c system_stm32u5xx.c stm32u5xx_ll_dlyb.c stm32u599j_discovery_ospi.c
